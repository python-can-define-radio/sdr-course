options:
  parameters:
    author: usacys
    generate_options: qt_gui
    id: basic_transmitter_GRCGEN
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: 100e6
    gain0: '0'
    if_gain0: '25'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
