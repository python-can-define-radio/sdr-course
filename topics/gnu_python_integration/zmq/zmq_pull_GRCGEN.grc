options:
  parameters:
    author: usacys
    generate_options: qt_gui
    id: zmq_pull_GRCGEN
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: 100.5e6
    gain0: '0'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', osmosdr_sink_0, '0']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
