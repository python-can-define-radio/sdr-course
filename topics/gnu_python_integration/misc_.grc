options:
  parameters:
    author: usacys
    generate_options: qt_gui
    id: misc_
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100.1e6
    step: '1'
    stop: 100.9e6
    value: 100.1e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: 100e6
    gain0: '0'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_pull_source_0, '0', osmosdr_sink_0, '0']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
