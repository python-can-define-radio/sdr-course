options:
  parameters:
    generate_options: qt_gui
    id: stuff
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ampl
  id: variable_qtgui_range
  parameters:
    gui_hint: (0, 0)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: hackrf_samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: ampl
    type: float
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(hackrf_samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(hackrf_samp_rate)
    tau: '75e-6'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (2, 0)
    name: '"original sig"'
    size: '600'
    srate: audio_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (2, 1)
    name: '"modulated"'
    size: '600'
    srate: hackrf_samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: (1, 0)
    name: '"original sig"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: hackrf_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: (1, 1)
    int_min: '-70'
    name: '"modulated"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_samp_rate
    interp: int(hackrf_samp_rate)
    taps: ''
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_wfm_tx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
