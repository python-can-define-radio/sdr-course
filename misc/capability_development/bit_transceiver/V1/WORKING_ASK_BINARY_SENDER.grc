options:
  parameters:
    author: usacys
    generate_options: qt_gui
    id: omeara_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: interp
  id: variable
  parameters:
    value: int(100e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    comment: |-
      You can ignore this. 
      It's just because there's a 
      newline at the end of the file 
      (and/or maybe an "end of file character") 
      that would cause trouble... I am causing
       it to simply appear as a zero.
    hi: '1'
    lo: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-97'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Must be only "a" and "b" 
      (0 and 1 respectively), and must 
      start with babababa
    file: /home/usacys/Desktop/omearatestfile.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: interp
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: This would be the better way to do it, but I couldn't figure it out.
    k: '8'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: 460.5e6
    gain0: '0'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    size: '8'
    srate: samp_rate/interp
    style1: '0'
    type: float
    update_time: '0.2'
  states: {}

connections:
- [analog_rail_ff_0, '0', blocks_repeat_0, '0']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
