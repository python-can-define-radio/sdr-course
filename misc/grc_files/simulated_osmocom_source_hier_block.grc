options:
  parameters:
    author: usacys
    generate_options: hb
    id: simulated_osmocom_source
    output_language: python
    title: Simulated osmocom Source
  states: {}

blocks:
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: fake_noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: fake_noise
  id: parameter
  parameters:
    label: Fake Noise
    type: eng_float
    value: '0.1'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF Gain
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: ipc:///tmp/osmocom_simulation_with_id_xcywkmsefyugud
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [zeromq_pull_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
