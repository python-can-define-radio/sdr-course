options:
  parameters:
    author: usacys
    generate_options: hb
    id: simulated_osmocom_sink
    output_language: python
    title: Simulated osmocom Sink
  states: {}

blocks:
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (if_gain + 1)/100
    type: complex
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF Gain
    type: eng_float
    value: '0'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: ipc:///tmp/osmocom_simulation_with_id_xcywkmsefyugud
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', zeromq_push_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
