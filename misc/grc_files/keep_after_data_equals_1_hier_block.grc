options:
  parameters:
    author: usacys
    generate_options: hb
    id: keep_after_data_equals_1
    output_language: python
    title: Keep after data equals 1 Hier Block
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_keep_first_stream_where_second_is_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass keep_first_stream_where_second_is_1(gr.basic_block):\n    \"\"\"Example:\n    if the first stream (in0) is 7.0, 2.0, -3.0, 5.0, -8.0\n    and the second stread is 1,  1,  0,  0,  1\n    the output will be 7.0, 2.0, -8.0.\n    \"\"\"\n\n    def __init__(self):\n\n        gr.basic_block.__init__(self,\n            name=\"Keep first stream where second is 1\",\n            in_sig=[np.float32, np.uint8],\n            out_sig=[np.float32])\n\n    def general_work(self, input_items, output_items):\n        #buffer references\n        in0 = input_items[0][:len(output_items[0])]\n        in1 = input_items[1][:len(output_items[0])]\n        outBuffer = output_items[0]\n        #process data\n        outData = in0[in1 == 1]\n        outBuffer[:len(outData)] = outData\n\n        #consume the inputs\n        self.consume(0, len(in0)) #consume port 0 input\n        self.consume(1, len(in1)) #consume port 1 input\n\n        #return produced\n        return len(outData)\n\n\n"
  states: {}
- name: epy_block_output_1_forever_once_input_equals_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class output_1_forever_once_input_equals_1(gr.sync_block):
          """Example:
          if the input stream is 0, 0, 1, 0, 0
          the output will be 0, 0, 1, 1, 1.
          """

          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Output 1 forever once input equals 1",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.reachedOne = False

          def work(self, input_items, output_items):
              inBuf = input_items[0]
              outBuf = output_items[0]
              if self.reachedOne:
                  outBuf[:] = 1.0
              else:
                  oneLoc = len(inBuf)
                  for idx, item in enumerate(inBuf):
                      if item == 1.0:                
                          self.reachedOne = True
                          oneLoc = idx
                          break
                  outBuf[:oneLoc] = 0.0
                  outBuf[oneLoc:] = 1.0
              
              return len(outBuf)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_float_to_uchar_0, '0', pad_sink_0, '0']
- [blocks_uchar_to_float_0, '0', epy_block_keep_first_stream_where_second_is_1, '0']
- [epy_block_keep_first_stream_where_second_is_1, '0', blocks_float_to_uchar_0, '0']
- [epy_block_output_1_forever_once_input_equals_1, '0', epy_block_keep_first_stream_where_second_is_1, '1']
- [pad_source_0, '0', blocks_uchar_to_float_0, '0']
- [pad_source_0, '0', epy_block_output_1_forever_once_input_equals_1, '0']

metadata:
  file_format: 1
