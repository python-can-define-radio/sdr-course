options:
  parameters:
    generate_options: qt_gui
    id: Air_to_Air_Receiver
    output_language: python
    title: Air_to_Air_Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '2'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This is an Air to Air Traffic Receiver

      Last time we used this, the students took a Yagi-Uda expedient antenna
      from Module E and pointed it straight in the air and met with success.
    note: READ ME
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 123.45e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', analog_am_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
