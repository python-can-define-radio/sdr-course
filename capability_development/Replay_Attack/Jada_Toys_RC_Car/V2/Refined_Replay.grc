options:
  parameters:
    generate_options: qt_gui
    id: Refined_Replay
    output_language: python
    title: Refined_Replay
  states: {}

blocks:
- name: Backwards
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '4'
    type: int
    value: '4'
  states: {state: disabled}
- name: Directions
  id: variable_qtgui_chooser
  parameters:
    label0: Forward
    label1: Backwards
    label2: Right
    label3: Left
    label4: 'Null'
    num_opts: '5'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: Forward
  id: variable_qtgui_push_button
  parameters:
    pressed: '0'
    released: '4'
    type: int
    value: '4'
  states: {state: disabled}
- name: Left
  id: variable_qtgui_push_button
  parameters:
    pressed: '3'
    released: '4'
    type: int
    value: '4'
  states: {state: disabled}
- name: Right
  id: variable_qtgui_push_button
  parameters:
    pressed: '2'
    released: '4'
    type: int
    value: '4'
  states: {state: disabled}
- name: channel_list
  id: variable
  parameters:
    value: sorted([2411, 2443, 2413, 2441, 2420, 2445, 2422, 2451, 2424, 2453, 2426, 2455, 2428, 2461, 2435, 2468, 2437, 2470, 2439, 2472])
  states: {state: disabled}
- name: freq_bw
  id: variable_qtgui_chooser
  parameters:
    label: 2441 GHz or 2472 GHz
    label0: 2441 GHz
    label1: 2472 GHz
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq_list
  id: variable
  parameters:
    value: '[2441, 2472]'
  states: {}
- name: freq_list_bw
  id: variable
  parameters:
    value: '[.8611, .8900]'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '32'
    widget: counter
  states: {}
- name: pointer_cl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: len(channel_list) -1
    value: '0'
  states: {state: disabled}
- name: pointer_fl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(freq_list) -1
    value: '0'
  states: {state: disabled}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411_Controls/2441_forward.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411_Controls/2441_reverse.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411_Controls/2441_right_turn.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411_Controls/2441_left_turn.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2472_Controls/2472_left_turn.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_1
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2472_Controls/2472_right_turn.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2472_Controls/2472_reverse.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2472_Controls/2472_forward.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: freq_bw
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: Directions
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: Directions
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    bw0: 'freq_list_bw[freq_bw] * 1e6 '
    freq0: freq_list[freq_bw] * 1e6
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_selector_1, '0']
- [blocks_file_source_0_0, '0', blocks_selector_1, '1']
- [blocks_file_source_0_0_0, '0', blocks_selector_1, '2']
- [blocks_file_source_0_0_0_0, '0', blocks_selector_1, '3']
- [blocks_file_source_0_0_0_0_0, '0', blocks_selector_1_0, '3']
- [blocks_file_source_0_0_0_1, '0', blocks_selector_1_0, '2']
- [blocks_file_source_0_0_1, '0', blocks_selector_1_0, '1']
- [blocks_file_source_0_1, '0', blocks_selector_1_0, '0']
- [blocks_null_source_0, '0', blocks_selector_1, '4']
- [blocks_null_source_0_0, '0', blocks_selector_1_0, '4']
- [blocks_selector_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_1, '0', blocks_selector_0, '0']
- [blocks_selector_1_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
