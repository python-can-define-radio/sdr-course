options:
  parameters:
    generate_options: qt_gui
    id: Replay
    output_language: python
    title: Replay
  states: {}

blocks:
- name: channel_list
  id: variable
  parameters:
    value: sorted([2411, 2443, 2413, 2441, 2420, 2445, 2422, 2451, 2424, 2453, 2426, 2455, 2428, 2461, 2435, 2468, 2437, 2470, 2439, 2472])
  states: {state: disabled}
- name: freq_list
  id: variable
  parameters:
    value: '[2411, 2441, 2472]'
  states: {}
- name: freq_list_bw
  id: variable
  parameters:
    value: '[.6729, .8611, .8900]'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '32'
    widget: counter
  states: {}
- name: pointer_cl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: len(channel_list) -1
    value: '0'
  states: {state: disabled}
- name: pointer_fl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(freq_list) -1
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411record.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2441record.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2472record.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: pointer_fl
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    bw0: 'freq_list_bw[pointer_fl] * 1e6 '
    freq0: freq_list[pointer_fl] * 1e6
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0_0_0, '0', blocks_selector_0, '2']
- [blocks_selector_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
