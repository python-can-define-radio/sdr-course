options:
  parameters:
    generate_options: qt_gui
    id: Record
    output_language: python
    title: Record
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '40'
    widget: counter
  states: {}
- name: channel_list
  id: variable
  parameters:
    value: sorted([2411, 2443, 2413, 2441, 2420, 2445, 2422, 2451, 2424, 2453, 2426, 2455, 2428, 2461, 2435, 2468, 2437, 2470, 2439, 2472])
  states: {state: disabled}
- name: freq_list
  id: variable
  parameters:
    value: '[2411, 2441, 2472]'
  states: {}
- name: freq_list_bw
  id: variable
  parameters:
    value: '[.6729, .8611, .8900]'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
    widget: counter
  states: {}
- name: pointer_cl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: len(channel_list) -1
    value: '0'
  states: {state: disabled}
- name: pointer_fl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: len(freq_list) -1
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411record.dll
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2411_Controls/2441_reverse.dll
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/usacys/Desktop/Paul/SDR/2472_Controls/2472_reverse.dll
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: pointer_fl
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: bb_gain
    bw0: freq_list_bw[pointer_fl] * 1e6
    freq0: freq_list[pointer_fl] * 1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_1, '0']
- [blocks_selector_0, '2', blocks_file_sink_1_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
