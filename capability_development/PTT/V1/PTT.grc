options:
  parameters:
    author: usacys
    generate_options: qt_gui
    id: pushtotalk
    output_language: python
    title: PTT
  states: {}

blocks:
- name: BB
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: PTT_Chooser
  id: variable_qtgui_chooser
  parameters:
    label0: Talk
    label1: Receive
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: receive_IF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: receive_RF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
  states: {}
- name: receive_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88e6
    step: 1e5
    stop: 108e6
    value: 88e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transmit_IF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '0'
  states: {}
- name: transmit_RF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
  states: {}
- name: transmit_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1e6
    step: 1e6
    stop: 6e9
    value: 1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: PTT_Chooser
    num_inputs: '2'
    num_outputs: '2'
    output_index: PTT_Chooser
    type: complex
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: transmit_freq
    gain0: transmit_RF
    if_gain0: transmit_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: BB
    freq0: receive_freq
    gain0: receive_RF
    gain_mode0: 'False'
    if_gain0: receive_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: int(samp_rate)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: '48000'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_tx_0, '0', low_pass_filter_1, '0']
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '1', low_pass_filter_1_0, '0']
- [low_pass_filter_1, '0', blocks_selector_0, '0']
- [low_pass_filter_1_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
