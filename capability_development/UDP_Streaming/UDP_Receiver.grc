options:
  parameters:
    generate_options: qt_gui
    id: UDP_Receiver
    output_language: python
    title: UDP_Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 1e6
    step: 1e6
    stop: 6e9
    value: 2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: freq*2
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This is the UDP Receiver. 
      The one using this file will need to type "0.0.0.0" into the IP Address. 
      It is IMPERATIVE that the port in the UDP Source is correct.
    note: READ ME. Click "Advanced"
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
