options:
  parameters:
    generate_options: qt_gui
    id: UDP_Sender
    output_language: python
    title: UDP_Sender
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 1e6
    step: 1e6
    stop: 6e9
    value: 2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: ''
    port: ''
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This is the UDP Sender. 
      The one using this file will need the destination IP address 
      and destination Port to properly stream data.

      The receiver should start their GRC first, then the transmitter (you).
    note: READ ME. Click "Advanced"
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_udp_sink_0, '0']

metadata:
  file_format: 1
